# Keil uVision project multitask.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: multitask +hex
  c flags: Optim=1
  c include: C:\FreeRTOSv10.0.1\FreeRTOS\Source\include;C:\FreeRTOSv10.0.1\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx;.
  asm include: C:\FreeRTOSv10.0.1\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s lcd link.h message_queue.c
  group FreeRTOS
    C:/FreeRTOSv10.0.1/FreeRTOS/Source/: list.c queue.c tasks.c
    C:/FreeRTOSv10.0.1/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/FreeRTOSv10.0.1/FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
